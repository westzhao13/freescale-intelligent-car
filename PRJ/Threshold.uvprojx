# Keil uVision project Threshold.uvprojx, settings and files
target Threshold (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1
  c include: ..\SRC\STARTUP;..\SRC\FWLIB\DELAY;..\SRC\FWLIB\GPIO;..\SRC\FWLIB\SYS;..\SRC\FWLIB\UART;..\SRC\FWLIB\WDOG;..\SRC\FWLIB\PIT;..\SRC\USER;..\SRC\HARDWARE\LED;..\SRC\\FWLIB\RTC;..\SRC\FWLIB\DMA;..\SRC\FWLIB\FTM;..\SRC\FWLIB\LPTM;..\SRC\FWLIB\ADC;..\SRC\FWLIB\DAC;..\SRC\FWLIB\SPI;..\SRC\HARDWARE\SPIFLASH;..\SRC\HARDWARE\SPILCD;..\SRC\FWLIB\I2C;..\SRC\FWLIB\PDB;..\SRC\HARDWARE\MMA845x;..\SRC\FWLIB\CAN;..\SRC\FWLIB\FLASH;..\SRC\FWLIB\SD;..\SRC\FWLIB\TSI;..\SRC\FWLIB\ENET;..\SRC\HARDWARE\Header
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group STARTUP
    ../SRC/STARTUP/: system_MK60DZ10.c startup_MK60DZ10.s
  group USER
    ../SRC/USER/: main.c isr.c
  group FWLIB
    ../SRC/FWLIB/SYS/: sys.c
    ../SRC/FWLIB/DELAY/: delay.c
    ../SRC/FWLIB/DMA/: dma.c
    ../SRC/FWLIB/FTM/: ftm.c
    ../SRC/FWLIB/GPIO/: gpio.c
    ../SRC/FWLIB/LPTM/: lptm.c
    ../SRC/FWLIB/PIT/: pit.c
    ../SRC/FWLIB/RTC/: rtc.c
    ../SRC/FWLIB/WDOG/: wdog.c
    ../SRC/FWLIB/ADC/: adc.c
    ../SRC/FWLIB/PDB/: pdb.c
    ../SRC/FWLIB/DAC/: dac.c
    ../SRC/FWLIB/SPI/: spi.c
    ../SRC/FWLIB/I2C/: i2c.c
    ../SRC/FWLIB/CAN/: can.c
    ../SRC/FWLIB/FLASH/: flash.c
    ../SRC/FWLIB/SD/: sd.c
    ../SRC/FWLIB/TSI/: tsi.c
    ../SRC/FWLIB/ENET/: enet.c
    ../SRC/FWLIB/UART/: uart.c
  group HARDWARE
    ../SRC/HARDWARE/CCD/: CCD.c
    ../SRC/HARDWARE/Oled/: Oled.c
    ../SRC/HARDWARE/L3G4200D/: L3G4200D.c
    ../SRC/HARDWARE/Menu/: Menu.c
    ../SRC/HARDWARE/ImageProcess/: ImageProcess.c
    ../SRC/HARDWARE/Balance/: Balance.c
    ../SRC/HARDWARE/Key/: Key.c
    ../SRC/HARDWARE/Led/: Led.c
    ../SRC/HARDWARE/Data/: Data.c
    ../SRC/HARDWARE/UartToPC/: UartToPC.c
    ../SRC/HARDWARE/MMA7361/: MMA7361.c
    ../SRC/HARDWARE/Motor/: Motor.c
    ../SRC/HARDWARE/Encoder/: Encoder.c
    ../SRC/HARDWARE/SpeedControl/: SpeedControl.c
    ../SRC/HARDWARE/DFlash/: DFlash.c
  group HEADER
    ../SRC/HARDWARE/Header/: Balance.h CCD.h Data.h ImageProcess.h includes.h Key.h L3G4200D.h Led.h Menu.h Oled.h UartToPC.h MMA7361.h Motor.h Encoder.h SpeedControl.h DFlash.h
